# Repository partlyhuman/loopycart

File README.md:

# the Floopy Drive 💕

This is a flashcart/devcart for the Casio Loopy. 

[☕️ Pre-built carts shipping worldwide on loopy.land/shop](https://loopy.land/shop)

[📖 User's Guide](https://github.com/partlyhuman/loopycart/wiki)

[<br>📺 Introductory Video](http://www.youtube.com/watch?v=_Q8cJwyDRfA)

To help find your way around:

* [pcb/flash-32mbit/](pcb/flash-32mbit/) The star of the show, the Floopy Drive PCB
* [flash-programmer/](flash-programmer/) Firmware that runs on the Floopy Drive, plus the PC interface for flashing it
* [cart-shell/](cart-shell/) 3D printable case for the Floopy Drive
* [labels/](labels/) Printable labels you can affix to a finished Floopy Drive
* [pcb/](pcb/) Other boards built along the way include a reverse-engineered cart that started it all
* [scans/](scans/) Scans of de-populated OEM Loopy games used as reference
* [data/](data/) Archive of relevant part datasheets for quick reference

Related repositories:

* [OSCR](https://github.com/sanni/cartreader) — I contributed a Casio Loopy adapter and code to the Open Source Cartridge Dumper, as well as a [makeshift adapter](https://github.com/sanni/cartreader/discussions/354#discussioncomment-10103848) that doesn't require an original cart connector
* [Loopy-Tools](https://github.com/kasamikona/Loopy-Tools) — a treasure trove of documentation and tooling around the Loopy by @kasamikona
* [Loopy-Schematics](https://github.com/kasamikona/Loopy-Schematics) - Schematics for various parts of, and accessories for, the Casio Loopy by @kasamikona
* [LoopyMSE](https://github.com/PSI-Rockin/LoopyMSE) — an open-source cross-platform Loopy emulator by @PSI-Rockin

### Contributors! 💕

None of this would be possible without the contributions of [@kasamikona](https://github.com/kasamikona) and [@kvanderlaag](https://github.com/kvanderlaag), with many, many additional thanks to the members of the [Unloved Budget Computer Hole](https://discord.gg/DH8cArK2) Discord server.

## KiCad design pcb/flash-32mbit/flash-32mbit.kicad_pcb

File pcb/README.md:

# Loopy flashcarts/devcarts

* [flash-32mbit](flash-32mbit/) — the Floopy Drive, with 32Mbit tri-voltage flash, and 256kbit SRAM
* [cart-connector](cart-connector/) — cart connector, footprint and symbol, for use in dumpers etc.
* [reverse-singlerom](reverse-singlerom/) — this is the AN1M cart design that we first reverse engineered
* [reverse-wanwan](reverse-wanwan/) — expanding upon that to try to document wanwan, schematic only so far

Some earlier revisions and experiments are in git history.

Parts:
BT1: CR2032; Keystone-3034TR-MFG
C1: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C4, C5, C6, C7: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; not fitted
D1: BAT54C; SOT-23
D2: PMEG4005CT,215; SOT-23-3
D3: BSS138; SOT-23
J1: LOOPY_Cart_Edge
R1: 1K2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R6, R9, R13: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4, R5, R8, R11, R14: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 2K2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: LH28F320SKTD-L70; TSOP-I-56_18.4x14mm_P0.5mm-HandSolder
U2: AS6C1008-55SIN; SOIC127P1410X300-32N; Manufacturer_Part_Number AS6C1008-55SIN; Mouser Part Number 913-AS6C1008-55SIN
U3: SN74LVC1G04; SOT-23-5
U4: RP2040-Tiny
U5, U6, U7: MCP23S17T-E/SS; SSOP-28_5.3x10.2mm_P0.65mm; Manufacturer_Part_Number MCP23S17T-E/SO; Mouser Part Number 579-MCP23S17T-E/SO

Connections:
+3V3: C4.1, D2.1, D3.1 (G), U1.15 (Vpp), U4.20 (3V3)
+5V: D2.2, J1.1 (+5V), J1.14 (+5V), J1.29 (+5V), J1.57 (+5V), J1.89 (+5V), R2.2, R6.2
+BATT: BT1.1 (+), R1.2
/A0: J1.33 (A0), U2.12 (A0), U6.21 (GPA0)
/A1: J1.32 (A1), U1.28 (A1), U2.11 (A1), U6.22 (GPA1)
/A2: J1.78 (A2), U1.27 (A2), U2.10 (A2), U6.23 (GPA2)
/A3: J1.30 (A3), U1.26 (A3), U2.9 (A3), U6.24 (GPA3)
/A4: J1.77 (A4), U1.25 (A4), U2.8 (A4), U6.25 (GPA4)
/A5: J1.70 (A5), U1.24 (A5), U2.7 (A5), U6.26 (GPA5)
/A6: J1.25 (A6), U1.23 (A6), U2.6 (A6), U6.27 (GPA6)
/A7: J1.69 (A7), U1.22 (A7), U2.5 (A7), U6.28 (GPA7)
/A8: J1.24 (A8), U1.20 (A8), U2.27 (A8), U6.1 (GPB0)
/A9: J1.68 (A9), U1.19 (A9), U2.26 (A9), U6.2 (GPB1)
/A10: J1.23 (A10), U1.18 (A10), U2.23 (A10), U6.3 (GPB2)
/A11: J1.67 (A11), U1.17 (A11), U2.25 (A11), U6.4 (GPB3)
/A12: J1.22 (A12), U1.13 (A12), U2.4 (A12), U6.5 (GPB4)
/A13: J1.26 (A13), U1.12 (A13), U2.28 (A13), U6.6 (GPB5)
/A14: J1.71 (A14), U1.11 (A14), U2.3 (A14), U6.7 (GPB6)
/A15: J1.27 (A15), U1.10 (A15), U2.31 (A15), U6.8 (GPB7)
/A16: J1.73 (A16), U1.8 (A16), U2.2 (A16), U7.21 (GPA0)
/A17: J1.72 (A17), U1.7 (A17), U7.22 (GPA1)
/A18: J1.74 (A18), U1.6 (A18), U7.23 (GPA2)
/A19: J1.76 (A19), U1.5 (A19), U7.24 (GPA3)
/A20: J1.28 (A20), U1.4 (A20), U7.25 (GPA4)
/A21: J1.31 (A21), U1.2 (~BE1L), U3.2, U7.26 (GPA5)
/D0: J1.35 (D0), U1.33 (DQ0), U2.13 (DQ0), U5.21 (GPA0)
/D1: J1.81 (D1), U1.35 (DQ1), U2.14 (DQ1), U5.22 (GPA1)
/D2: J1.37 (D2), U1.38 (DQ2), U2.15 (DQ2), U5.23 (GPA2)
/D3: J1.38 (D3), U1.40 (DQ3), U2.17 (DQ3), U5.24 (GPA3)
/D4: J1.40 (D4), U1.44 (DQ4), U2.18 (DQ4), U5.25 (GPA4)
/D5: J1.85 (D5), U1.46 (DQ5), U2.19 (DQ5), U5.26 (GPA5)
/D6: J1.41 (D6), U1.49 (DQ6), U2.20 (DQ6), U5.27 (GPA6)
/D7: J1.86 (D7), U1.51 (DQ7), U2.21 (DQ7), U5.28 (GPA7)
/D8: J1.42 (D8), U1.34 (DQ8), U5.1 (GPB0)
/D9: J1.88 (D9), U1.36 (DQ9), U5.2 (GPB1)
/D10: J1.44 (D10), U1.39 (DQ10), U5.3 (GPB2)
/D11: J1.90 (D11), U1.41 (DQ11), U5.4 (GPB3)
/D12: J1.82 (D12), U1.45 (DQ12), U5.5 (GPB4)
/D13: J1.83 (D13), U1.47 (DQ13), U5.6 (GPB5)
/D14: J1.39 (D14), U1.50 (DQ14), U5.7 (GPB6)
/D15: J1.84 (D15), U1.52 (DQ15), U5.8 (GPB7)
/F16: J1.16 (PB1), R2.1
/F61: J1.61 (PB3), R6.1
/MCPA0_CS: U4.6 (GP6), U6.11 (~CS)
/MCPA1_CS: U4.7 (GP7), U7.11 (~CS)
/MCPD_CS: U4.5 (GP5), U5.11 (~CS)
/OE: J1.56 (~OE), U1.54 (~OE), U2.24 (OE#), U7.1 (GPB0)
/RAMCE: J1.9 (~CS2), U2.22 (CE#), U7.2 (GPB1)
/RAMWE: J1.11 (~RAMWE), R14.2, U2.29 (WE#), U7.3 (GPB2)
/RESET: J1.36 (~RESET), R4.1, U1.16 (~RP), U2.30 (CE2), U7.6 (GPB5)
/ROMCE: J1.54 (~CS6), R5.2, U1.14 (~BE0), U7.4 (GPB3)
/ROMWE: R3.2, U1.55 (~WE), U7.5 (GPB4)
/RX_D0: J1.20 (PB8), R13.2
/SPI_CLK: U4.2 (GP2), U5.12 (SCK), U6.12 (SCK), U7.12 (SCK)
/SPI_RX: U4.4 (GP4), U5.14 (SO), U6.14 (SO), U7.14 (SO)
/SPI_TX: U4.3 (GP3), U5.13 (SI), U6.13 (SI), U7.13 (SI)
/TX_D0: J1.17 (PB9), R9.2
/UART0_RX: R9.1, R10.1, U4.13 (GP13)
/UART0_TX: D3.2 (S), R11.2, U4.12 (GP12)
/~A21: U1.3 (~BE1H), U3.4
/~INSERTED: J1.47 (GND), R8.2, U4.14 (GP14), U5.18 (~RESET), U6.18 (~RESET), U7.18 (~RESET)
GND: BT1.2 (-), C1.1, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, J1.13 (GND), J1.45 (GND), J1.75 (GND), R4.2, R10.2, R11.1, U1.21 (GND), U1.42 (GND), U1.48 (GND), U2.16 (VSS), U3.3 (GND), U4.21 (GND), U5.10 (VSS), U5.15 (A0), U5.16 (A1), U5.17 (A2), U6.10 (VSS), U6.16 (A1), U6.17 (A2), U7.10 (VSS), U7.15 (A0), U7.17 (A2)
unnamed: D1.1, R1.1
unnamed: D3.3 (D), R12.2, R13.1
VCC: C2.1, C3.1, C5.2, C6.2, C7.2, D1.2, D2.3, R3.1, R5.1, R8.1, R12.1, U1.9 (Vcc), U1.31 (~BYTE), U1.37 (Vcc), U1.43 (Vcc), U1.56 (~WP), U3.5 (VCC), U5.9 (VDD), U6.9 (VDD), U6.15 (A0), U7.9 (VDD), U7.16 (A1)
VMEM: C1.2, D1.3, R14.1, U2.32 (VCC)

Notes on the sheet:
Use one of the GND pins, which are connected on the console side, to sense when the cart is connected and powered. Low when cart inserted, high otherwise. Opposite of RESET which is high when inserted, low when being reset.
Power SRAM from battery (<3V) when disconnected Power SRAM from VCC when connected to pico (3.3V) or loopy (5V) Prevent VCC from charging battery
POWER
RAM
Shares decoupling cap with neighbouring C2
ROM
Loopy TX / Pico RX Divide down Loopy 5V to Pico 3.5V
CE# is ACTIVE LOW (standby when HIGH) CE2 is ACTIVE HIGH (standby when LOW)
Note SPI address (A0-A2) no longer used, using individual CS lines However, changing would require breaking firmware change
CART EDGE
mcpAddr0
mcpAddr1
This flash uses "Bank selection" instead of a high address bit. This generates the proper BE1L and BE1H from A21
Programming power only when pico on No programming power when pico off + decoupling
Pullups, may indicate features to Loopy
Serial debugging (optional, do not populate if not needed)
Pico TX / Loopy RX Level shift 3.3V to 5V Prevent unpowered Pico from sinking to 0, seen as invalid data by UART
SERIAL
SPI IO Expanders, sharing a single SPI bus
~{BYTE} low places the device in x8 mode, so we tie it high for 16-bit DQ input/output
CONTROLLER
CONTROLLER I/O
mcpData

Board: 2 copper layers, 96.3 x 76.2 mm, 33 parts (1 on the bottom side), 66 nets.

Other parts of the board:
H1, H2: MountingHole_5mm

File pcb/flash-32mbit/production/Floopy_Drive_10_2024-01-29_21-39-53/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BT1,Keystone-3034TR-MFG,1,CR2032,
C1,0805,1,1u,
"C2, C4, C5, C6, C7",0805,5,0.1u,
D1,SOT-23,1,BAT54C,
D2,SOT-23-3,1,PMEG2005CT_215,
D3,SOT-23,1,BSS138,
J1,LOOPY_Cart_Edge,1,~,
R1,0805,1,1K2,
R10,0805,1,2K2,
"R11, R3, R4, R8",0805,4,100K,
R12,0805,1,10K,
"R13, R2, R6, R9",0805,4,1K,
"R14, R5",0805,2,100K,DNP
U1,TSOP-I-56_18.4x14mm_P0.5mm-HandSolder,1,LH28F320SKTD-L70,
U2,SOIC127P1410X300-32N,1,AS6C1008-55SIN,
U3,SOT-23-5,1,SN74LVC1G04,
U4,RP2040-Tiny,1,RP2040-Tiny,
"U5, U6, U7",SSOP-28_5.3x10.2mm_P0.65mm,3,MCP23S17T-E/SS,

## KiCad design pcb/led-power-board/led-power-board.kicad_pcb

Board: 2 copper layers, 27.2 x 21.0 mm, 6 parts (1 on the bottom side), 3 nets.

Parts:
D1: LED; LED_D5.0mm
J1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
M1: MountingHole_3mm
M2, M3: MountingHole_2mm
R1: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
unnamed: D1.2 (A), J1.1
unnamed: D1.1 (K), R1.2
unnamed: J1.2, R1.1

## KiCad design pcb/singlerom-dev/singlerom-dev.kicad_pcb

Parts:
BT1: CR2032; Keystone-3034TR-MFG
C1: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: BAV70LT1G; SOT-23
D2: BAT54C; SOT-23
J1: LOOPY-Edge-Connector
R1, R2: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4, R5: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 1.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: AS6C6264-55SCN; SOP-28_Customized
U2: MX29LV160DBTI-70G; SOP50P2000X120-48N; Manufacturer_Part_Number MX29LV160DBTI-70G
U4: Pi Pico; RPi_Pico_SMD_TH
U5: TCA9539PWR; TSSOP-24_4.4x7.8mm_P0.65mm

Connections:
+BATT: BT1.2 (+), R6.1
/A0: J1.32 (A0), U1.9 (A1), U2.25 (A0), U4.6 (4)
/A1: J1.78 (A1), U1.8 (A2), U2.24 (A1), U4.7 (5)
/A2: J1.30 (A2), U1.7 (A3), U2.23 (A2), U4.9 (6)
/A3: J1.77 (A3), U1.21 (A10), U2.22 (A3), U4.10 (7)
/A4: J1.70 (A4), U1.6 (A4), U2.21 (A4), U4.11 (8)
/A5: J1.25 (A5), U1.23 (A11), U2.20 (A5), U4.12 (9)
/A6: J1.69 (A6), U1.24 (A9), U2.19 (A6), U4.14 (10)
/A7: J1.24 (A7), U1.25 (A8), U2.18 (A7), U4.15 (11)
/A8: J1.68 (A8), U1.2 (A12), U2.8 (A8), U4.16 (12)
/A9: J1.23 (A9), U1.3 (A7), U2.7 (A9), U4.17 (13)
/A10: J1.67 (A10), U1.4 (A6), U2.6 (A10), U4.19 (14)
/A11: J1.22 (A11), U1.5 (A5), U2.5 (A11), U4.20 (15)
/A12: J1.26 (A12), U2.4 (A12), U4.21 (16)
/A13: J1.71 (A13), U2.3 (A13), U4.22 (17)
/A14: J1.27 (A14), U2.2 (A14), U4.24 (18)
/A15: J1.73 (A15), U2.1 (A15), U4.25 (19)
/A16: J1.72 (A16), U2.48 (A16), U4.26 (20)
/A17: J1.74 (A17), U2.17 (A17), U4.27 (21)
/A18: J1.76 (A18), U2.16 (A18), U4.29 (22)
/A19: J1.28 (A19), U2.9 (A19), U4.37 (23)
/D0: J1.35 (D0), U1.18 (DQ6), U2.29 (Q0), U5.4 (P00)
/D1: J1.81 (D1), U1.17 (DQ5), U2.31 (Q1), U5.5 (P01)
/D2: J1.37 (D2), U1.16 (DQ4), U2.33 (Q2), U5.6 (P02)
/D3: J1.38 (D3), U1.15 (DQ3), U2.35 (Q3), U5.7 (P03)
/D4: J1.40 (D4), U1.13 (DQ2), U2.38 (Q4), U5.8 (P04)
/D5: J1.85 (D5), U1.12 (DQ1), U2.40 (Q5), U5.9 (P05)
/D6: J1.41 (D6), U1.11 (DQ0), U2.42 (Q6), U5.10 (P06)
/D7: J1.86 (D7), U1.19 (DQ7), U2.44 (Q7), U5.11 (P07)
/D8: J1.42 (D8), U2.30 (Q8), U5.13 (P10)
/D9: J1.88 (D9), U2.32 (Q9), U5.14 (P11)
/D10: J1.44 (D10), U2.34 (Q10), U5.15 (P12)
/D11: J1.90 (D11), U2.36 (Q11), U5.16 (P13)
/D12: J1.82 (D12), U2.39 (Q12), U5.17 (P14)
/D13: J1.83 (D13), U2.41 (Q13), U5.18 (P15)
/D14: J1.39 (D14), U2.43 (Q14), U5.19 (P16)
/D15: J1.84 (D15), U2.45 (Q15/A-1), U5.20 (P17)
/F16: J1.16 (F16), R2.2
/F61: J1.61 (F61), R1.2
/I2C_RESET: U4.4 (2), U5.3 (~RESET)
/I2C_SCL: U4.2 (1), U5.22 (SCL)
/I2C_SDA: U4.1 (0), U5.23 (SDA)
/OE: J1.56 (OE), U1.22 (*OE), U2.28 (OE#), U4.34 (28)
/PICO_GND: C3.1, U4.3 (GND), U5.2 (A1), U5.12 (GND), U5.21 (A0)
/PICO_ROMWE: R3.2, U2.11 (WE#), U4.32 (27)
/RAMA0: J1.33 (RAMA0), U1.10 (A0)
/RAMCS1: J1.9 (~RAMCS1), U1.20 (*CE), U4.31 (26)
/RAMCS2: J1.36 (RAMCS2), R4.2, U1.26 (CE2)
/RAMWE: J1.11 (~RAMWE), U1.27 (*WE)
/ROMCE: J1.54 (~ROMCE), R5.2, U2.26 (CE#), U4.35 (29)
GND: BT1.1 (-), C1.1, C2.2, J1.13 (GND), J1.45 (GND), J1.47 (GND), J1.75 (GND), R4.1, U1.14 (VSS), U2.27 (GND_1), U2.46 (GND_2), U4.38 (GND)
unnamed: C1.2, D1.3 (A), U1.28 (VCC)
unnamed: D1.1 (K), R6.2
unnamed: D2.1, D2.2, U4.36 (3V3)
VCC: C2.1, C3.2, D1.2 (K), D2.3, J1.1 (VCC), J1.14 (VCC), J1.29 (VCC), J1.57 (VCC), J1.89 (VCC), R1.1, R2.1, R3.1, R5.1, U2.12 (RESET#), U2.14 (WP#/ACC), U2.37 (VCC), U2.47 (BYTE#), U5.24 (VCC)

Notes on the sheet:
RAMCS2 low when disconnected standby mode
Select power source, prevent battery charging
Pico acts as a switch providing a path from VCC to GND So IO expand only gets power when pico inserted?
/CE works same
Power from USB only
RAM
ROM
MaskROM: We should behave the same as this
CART EDGE
Flash
AS6C6264-55SIN, modern available replacement for HM9264B, should be interchangeable
Feature detect pins?
When ROMCE disconnected (no cart) pull CE high for standby
/OE active low observed
When Pico disconnected WE pulled high to write protect
Provide 3V power to board when plugged into USB
Note OE, address, data bus all shared between RAM/ROM
PROGRAM

Board: 2 copper layers, 96.3 x 76.2 mm, 21 parts (1 on the bottom side), 55 nets.

Other parts of the board:
H1, H3: MountingHole_5mm
H2, H4: MountingHole_3.2mm_M3

## Code that names these connections

File flash-programmer/pico/pico.ino:

#include <SPI.h>
#include <MCP23S17.h>
#include <Adafruit_TinyUSB.h>
#include <Adafruit_NeoPixel.h>
#include <LittleFS.h>
#include "generated.h"

#define HW_REVISION 8
// The MCP23S17 is rated for 10MHz
#define SPI_SPEED 10000000
#define DEBUG_LED

// Delays one clock cycle or 7ns | 133MhZ = 0.000000007518797sec = 7.518797ns
#define NOP __asm__("nop\n\t")
#define HALT while (true)

#define ADDRBITS 22
// 64kb blocks
#define FLASH_BLOCK_SIZE 0x010000
// two 2mb banks
#define FLASH_BANK_SIZE 0x200000
#define FLASH_SIZE FLASH_BANK_SIZE << 1
#define CMD_RESET 0xff
#define PIN_INSERTED 14
#define USB_BUFSIZE 64

WEBUSB_URL_DEF(landingPage, 1, "f.loopy.land");
Adafruit_USBD_WebUSB usb_web;

// ~RESET is pulled high when pico is powered up, >=99 means dummy reset pin
#define MCP_NO_RESET_PIN 100
// SPI addresses for MCP23017 are: 0 1 0 0 A2 A1 A0
// Note we almost certainly don't need differing addresses any more since REV6 gave each a unique CE, but no harm keeping it
MCP23S17 mcpData = MCP23S17(5, MCP_NO_RESET_PIN, 0b0100000);   //Data IO, D0-D15, Address 0x0
MCP23S17 mcpAddr0 = MCP23S17(6, MCP_NO_RESET_PIN, 0b0100001);  //Address IO, A0-A15, Address 0x1
MCP23S17 mcpAddr1 = MCP23S17(7, MCP_NO_RESET_PIN, 0b0100010);  //Address and control IO, A16-A21, OE, RAMCE, RAMWE, ROMCE, ROMWE, RESET, Address 0x2

// sprintf buffer
char S[USB_BUFSIZE];
// timing operations
unsigned long stopwatch;

// status register
uint16_t SRD;
#define SR(n) bitRead(SRD, n)

#define RED  0xFF0000
#define BLUE 0x0000FF
Adafruit_NeoPixel led(1, 16, NEO_GRB);

inline void ledColor(uint32_t c) {
  led.setPixelColor(0, c);
  led.show();
}

void flashLed(int n, int d = 100) {
  for (int i = 0; i < n; i++) {
    led.setPixelColor(0, 0xff0000);
    led.show();
    delay(d / 2);
    ledColor(0);
    led.show();
    delay(d / 2);
  }
}

// Changing the port mode is superslow so let's cache it
enum DataBusMode { READ,
                   WRITE };
DataBusMode databusMode = WRITE;

inline void ioReadMode(MCP23S17 *mcp) {
  mcp->setPortMode(0, A);
  mcp->setPortMode(0, B);
}

inline void databusReadMode() {
  if (databusMode == READ) return;
  ioReadMode(&mcpData);
  databusMode = READ;
}

inline void ioWriteMode(MCP23S17 *mcp) {
  mcp->setPortMode(0b11111111, A);
  mcp->setPortMode(0b11111111, B);
}

inline void databusWriteMode() {
  if (databusMode == WRITE) return;
  ioWriteMode(&mcpData);
  databusMode = WRITE;
}

// NOTE address is in bytes, though we write words
inline void setAddress(uint32_t addr) {
  // cache address and only set bits that changed
  static uint32_t lastAddr = 0;
  uint32_t diff = addr ^ lastAddr;

  // // A0-A7
  // if ((diff & 0x000000ff) != 0) {
  //   mcpAddr0.setPort(addr & 0xff, A);
  // }
  // // A8-A15
  // if ((diff & 0x0000ff00) != 0) {
  //   mcpAddr0.setPort((addr >> 8) & 0xff, B);
  // }

  // A0-A15
  if ((diff & 0x0000ffff) != 0) {
    mcpAddr0.setPort(addr & 0xff, (addr >> 8) & 0xff);
  }

  // A16-A21
  if ((diff & 0x00ff0000) != 0) {
    mcpAddr1.setPort((addr >> 16) & 0xff, A);
  }

  lastAddr = addr;
}

// Control pins migrated to io expanders so build a bitmask with these. They're all active low so & these:
const uint8_t IDLE = 0xff;
const uint8_t OE = ~(1 << 0);
const uint8_t RAMCE = ~(1 << 1);
const uint8_t RAMWE = ~(1 << 2);
const uint8_t ROMCE = ~(1 << 3);
const uint8_t ROMWE = ~(1 << 4);
const uint8_t RESET = ~(1 << 5);

// Any bits in bitmask that are 0 will go low (active), bits are 0=OE 1=RAMCE 2=RAMWE 3=ROMCE 4=ROMWE 5=RESET
inline void setControl(uint8_t bitmask = IDLE) {
  static uint8_t lastControl = 0;
  if (bitmask != lastControl) {
    mcpAddr1.setPort(bitmask, B);
  }
  lastControl = bitmask;
}

inline uint16_t readWord() {
  return (mcpData.getPort(B) << 8) | mcpData.getPort(A);
}

inline uint8_t readByte() {
  return mcpData.getPort(A);
}

inline void writeWord(uint32_t addr, uint16_t word) {
  setAddress(addr);
  // In testing, caching last write is slower
  mcpData.setPort(word & 0xff, (word >> 8) & 0xff);
}

inline void writeByte(uint32_t addr, uint8_t byte) {
  setAddress(addr);
  mcpData.setPort(byte, A);
}

// Ensures strings are sent modulo the USB buffer size
// Pass no parameters to use the shared string buffer S (after sprintf for example)
void echo_all(const char *buf = NULL) {
  if (!usb_web.connected()) return;

  if (buf == NULL) {
    buf = S;
    // S is already the correct size
  } else {
    // A string is provided, this will pad it to buffer size and fill with NUL
    strncpy(S, buf, USB_BUFSIZE);
  }

  usb_web.write(S, USB_BUFSIZE);
  usb_web.flush();

  // if (Serial) {
  //   Serial.write(buf);
  //   Serial.flush();
  // }
}

void echo_ok() {
  echo_all("!OK\r");
}

## Commit log (part)

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2023-03-04 ignores
2023-03-04 Scans of XK-403 Dream Change without components
2023-03-04 Add link to Google Sheet
2023-03-05 start reversing single rom cart
2023-03-05 reversing some pins
2023-03-05 Continue tracing
2023-03-05 Traced all signal routes
2023-03-05 Annotating power nets
2023-03-06 Update power nets
2023-03-06 Adds power to reverse engineered cart
2023-03-06 Adds feature detect pins, fixes DRC errors
2023-03-07 Add oki pcm sound chip datasheet
2023-03-07 Adds some comments
2023-03-08 Annotates cart edge symbol
2023-03-08 Update notes, pass ERC, pass DRC
2023-03-08 Replicate no soldermask area around fingers
2023-03-21 Adds devcart rev 0
2023-04-09 tweaks
2023-04-10 Adds Pi Pico header + IO expander for on-board programming, starting over with manual routing
2023-04-11 Add header pin breakout for SOP44 maskrom
2023-04-11 Work on rerouting devcart
2023-04-11 SOP44 narrow breadboard adapter
2023-04-16 WIP rerouting devcart
2023-04-16 Correcting wrong flash IC, footprint, symbol. Still needs rerouting but removed incorrect one.
2023-04-16 Fix schematic with 16mbit
2023-04-16 Schematic update better matching sram mapping
2023-04-17 Forget FRAM for now, redesign around pin compatible SRAM, nuke old routes
2023-04-17 Routing
2023-04-19 Replicate power path controller for SRAM from original
2023-04-19 Nudging clearances
2023-04-30 WIP some fixes, not completed but didn't want to leave broken
2023-04-30 flash programmer client and microcode
2023-05-01 Flash programmer working?
2023-05-01 Pretty much pointless changes
2023-05-08 Speed improvements though bottlenecked by i2c expander, more accurate dumping
2023-05-10 Quick patching BYTE issue
2023-05-10 Push gerber updates
2023-05-10 Update diode part
2023-05-12 Adds pinout data @phil
2023-05-12 Adds what I know to cart pinout
2023-05-13 Remove maskrom breakout
2023-05-16 Adds datasheets for chips found on wanwan
2023-05-16 WIP on wanwan schematic, all cart edge pins identified
2023-05-16 Updating more pins on wanwan
2023-05-16 WIP reverse engineering wanwan cart's extra circuitry
2023-05-17 Convert Pico to castellated footprint and reroute; add logo
2023-05-17 FLOOPYDRIVE
2023-05-21 Very experimental changes in separate directory
2023-05-21 Thou shalt double-check markdown syntax
2023-05-21 Describe DIP switch functions
2023-05-22 Added BAT54C to Pico 3V3 line; coin cell moved to rear; forehead removed
2023-05-23 Removing test jumpers and points
2023-05-28 32mbit and 3.3v updates to schematic
2023-05-29 vreg and resistor packs
2023-05-29 Copy project to new directory
2023-05-29 Restore original from git
2023-05-29 Add readme for diff versions
2023-05-29 Switch Flash part to Sharp LH28F320SKTD-L70
2023-05-29 Preliminary routing
    This sucks, so feel free to reroute literally anything or move stuff around
2023-05-30 Complete initial route
2023-05-30 Update IO expander 3D model
2023-05-30 Add 10K pulldown to flash Vpp, decoupling cap
2023-05-30 Adds datasheet, decouples IO exp
2023-06-02 Detect padding
2023-06-05 Minor fix idk
2023-06-09 I2C speedup, fix erase status, fix slowdown on FFFF blocks
2023-06-09 Un-screw line endings hopefully
2023-06-09 Fix last word skipped
2023-06-10 Add protocol versioning in preparation for changes
2023-06-14 Adds cart connector footprint
2023-06-16 Minor cart edge footprint changes
2023-06-22 Archives SH-1 datasheet
2023-06-23 First stab at rev.3 firmware
2023-06-23 Working flash, inspect, erase, status. Still very primitive
2023-06-24 Add hand-solder footprint for Sharp Flash
2023-06-24 Change physical stackup to show board thickness of 1mm
2023-06-25 Use multi-byte write flashing
2023-06-25 Refactoring out old stuff
2023-06-25 Minor tweaks
2023-06-25 Pointless tidying up
2023-06-25 Correct value for io expanders, mcp2317 is not the same as mcp2318
2023-06-25 Touches up the web interface slightly
2023-06-26 SRAM added!
2023-06-27 Restoring LED while flashing
2023-06-27 Add binary for pico
2023-06-28 Adds lock bit clear to erase routine, common status check routine
2023-06-28 Fixes multibyte programming upper bank
2023-06-28 Add STL files for 3D-printed cartridge shell
2023-06-28 Beef up screw holes on rear cart shell
2023-06-29 Mostly meaningless changes, but using continuous read SRAM reading, and keeping bus low-impedance while SRAM wants to control bus
2023-06-29 Update binary
2023-07-01 Adds cart ID, and pico flash based SRAM restore/backup
2023-07-01 Official f.loopy.land url, better fs reporting, favicon
2023-07-01 Adds latest firmware binary
2023-07-03 Implement cart database & swapping
2023-07-03 Minor improvements to type checking and csv parsing
2023-07-10 Cart model update
2023-07-16 Fixes to sram processes
2023-07-16 Adds RP2040-Tiny footprint and symbol
2023-07-16 Update schematic to use rp2040-tiny
2023-07-16 Adds 256kb SRAM to schematic, some reorganizing of libraries
2023-07-16 Applies changes to PCB, no routing
2023-07-16 Stealing the bus routing from rev.2
2023-07-22 Flash routed but the orientation is misleading, savepoint...
2023-07-22 Checkpoint
2023-07-22 Routing RP2040-Tiny revision
2023-07-23 Production tweaks
2023-07-23 Pullup RAMCE since new SRAM only has one chip select pin
2023-07-24 Cleanup schematic
2023-08-13 Update to use @kasamikona's edge connector (renumbered to match)
2023-08-13 Adds rp2040-tiny 3d model
2023-08-13 Minor fix to RP2040-Tiny footprint
2023-08-13 Firmware update for rev4 boards
2023-08-14 rev4 firmware binary, demote severity of DRC for soldermask on edge
2023-08-19 Adds reference models for rev4 cart shell
2023-08-19 Creates label dir
2023-08-24 Fixes dumping bug on firmware, improves web interface with progress, routines to dump and parse header, dumping correct size based on dumped header
2023-08-24 Fixes SRAM size calculation adding final byte
2023-08-27 Incremental programming so we can monitor progress on the client
2023-08-27 Adds keepouts for case geometry
2023-08-27 Moves components out of keepout areas, RESET no longer connected
2023-08-27 Gives each expander its own CS line (help bus interference?)
2023-08-27 checkpoint - routed uart0
2023-08-27 Connects two serial ports from Loopy
2023-08-27 Updates shell with wider space for ribbon found on another seller's Pico Tiny, and updated pcb model
2023-08-27 Indicates optional dev-only components
2023-08-29 Reverts powering pico from loopy
2023-09-09 Firmware changes for rev5
2023-09-11 Fixes SRAM low power mode on schematic, needs routing
2023-09-14 rev6 RC
2023-09-15 Nudges to increase flood volume
2023-09-17 Adds serial forwarding
2023-09-17 Cleaning up old boards and updating readmes
2023-09-24 Fixes sram getting byte 0 set to 0; SRAM programmer improvements
2023-09-26 Format SRAM to 1s instead of 0s
2023-09-28 Rev7 hardware changes: new SRAM part
2023-09-28 Remove redundant pullups?
2023-09-28 Tidying, using RESET to power down flash, marking potentially redundant pullups
2023-09-28 Now that asserting RESET low keeps some things safe, let pico drive RESET high only when ready
2023-09-28 /RESET pulled low, power up and down conditions should be covered by this and extra control pullups should be redundant
2023-10-21 REV7 changes for larger SRAM mostly
2023-10-22 Fixes voltage divider resistor order
2023-10-22 Stealth patching Little Romance
2023-10-22 Revert "Fixes voltage divider resistor order"
    This reverts commit 804d36860d2d035c957d0a79ec73a7ea4df5a67d.
2023-10-22 Corrects serial RX and fixes issue with unpowered serial TX
2023-10-22 Rev8 changes mostly to serial
2023-10-23 Micro minor tweaks
2023-10-23 Reorganize power nets
2023-10-23 Cleaning up REV8 design
2023-10-23 Consolidating blocker diodes and using higher current PMEG2005CT
2023-11-05 Removing serial patching, good with R8 hardware, committing uf2
2023-11-06 Ensure 3d prints current
2023-11-14 Adding usage
2023-11-14 update docs
2023-11-14 Adding notes on disconnecting
2023-11-14 Minor docs updates
2023-11-18 Adds custom USB identifier to built firmware
2023-11-18 Changes serial TX pullup to be weaker
2023-11-20 Adds easy mode
2023-11-20 Firmware & flasher updates for better sram
2023-11-21 Speed gains while flashing from minimizing MCP use
2023-11-21 Let's try automating commit hash?
2023-11-21 Fixes un-padding
2023-11-21 Backup sram on power
2023-11-21 Update web to match FW, don't backup save as it's done automatically
2023-11-25 Corrects vendor ID on USB device filter
2023-12-05 Separate device IDs in different modes
2023-12-05 Make serial debug baud rate dynamic
2023-12-05 Inconsequential changes that were sitting on my disk, was benchmarking different MCP address techniques
2023-12-05 Update binary with dynamic USB device name and bumped libraries, bump version
2023-12-05 Nicknames
2023-12-05 Firmware binary & version bump
2023-12-07 VERY WIP rgb flex cable
2023-12-08 Show the download link in the flasher itself
2023-12-08 Update usage guide
2023-12-08 Moving user guide to wiki
2023-12-08 Update wiki link
2023-12-08 just need to send one more byte to get floopy land to parse it on connect
2023-12-08 Fixes FW hash checking
2023-12-09 Rev9 minor change that moves F16/F61 pullups far away from edge connector
2023-12-10 Cart shell improvements
2023-12-12 Replacement LED power board with place for resistor
2023-12-16 Block-by-block erasing, tap to choose a file as well as drag/drop, all sizes in bytes not words
2023-12-16 Minor cleanups
2023-12-16 Flasher: adds user guide link, gives drop area more space
2023-12-27 Flasher remember last state of Advanced checkbox
2023-12-28 Fixes to make send/receives always a single 'packet' size, adding QA functionality, builds to come
2023-12-28 Fixes broken nickname method, minor cleanups
2023-12-31 Plain-ass label
2024-01-01 Adds stls with mouse ears for better adhesion
2024-01-01 Ugh, lots of fixes, support for QA, new build follows
2024-01-01 New build 84c7776
2024-01-07 Add QA npm task
2024-01-09 Unignore CSV to allow bom etc to be added
2024-01-13 Win7 theme
2024-01-14 Adds some better error dialogs
2024-01-14 Addresses some visual and text issues, adds recommended browser alternatives
2024-01-14 Makes error dialog red
2024-01-14 Makes background un-tappable while dialog is up
2024-01-14 Focus ok button when dialog is popped up for easier keyboard nav
2024-01-15 Automatic handling of connect & disconnect, give a little warning if trying to reload/close during operations
2024-01-15 Send less ambiguous noop command on connect
2024-01-15 Busy logo animation
2024-01-15 Firmware bugfixes: stalls on finishing some flash writes, only erasing needed amount of SRAM, possible misinterpretation of header when sram still selected
2024-01-15 Await OK instead of playing waiting game, but needs fw 82c4a64
2024-01-15 Help text for additional possible misuse
2024-01-16 Removing even more redundant control code
2024-01-16 Firmware 8ab2047 binary, and adding firmware update instructions
2024-01-16 Minor visual tweaks to programmer, more like GUI with less user selection/drag allowed
2024-01-16 Widens battery solder pads
2024-01-16 Brings more attention to flashing being finished
2024-01-18 Updates screenshots
2024-01-30 Rev 10 - changing MCP23S17 from SOP28 to SSOP28
2024-01-30 Converting RP2040 to SMD-only pads
2024-01-30 Flips backwards text on rear silk
2024-01-30 Revert "Flips backwards text on rear silk"
    This reverts commit 23c83f32a1717887e789bbf7f9e156f244039a19.
2024-01-30 Revert "Converting RP2040 to SMD-only pads"
    This reverts commit 3f45febaba06878acc33683eaa9a11db4d2374d0.
2024-01-30 Disallows direct connection between pads, updates schematic to reflect new PMEG part and restoring the DNP components we have been using
2024-02-04 Updated labels from @VideoDojo, cleaned up, fixed wonky text, wider bleed, crop marks, updated copyleft
2024-02-17 New ding sound with improved emulation
2024-03-17 Fixes transparency in label export
2024-05-06 Split QA harness out, add batch wipe QA tool
2024-05-09 Offline access to f.loopy.land
2024-05-09 Looser cache matching
2024-06-09 Remove aborted wanwan reversing, see https://github.com/kasamikona/Loopy-Schematics
2024-08-13 Update README.md
    Moved YouTube

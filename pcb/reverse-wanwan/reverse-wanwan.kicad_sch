File: pcb/reverse-wanwan/reverse-wanwan.kicad_sch (KiCad schematic)
At the start: 35 parts, among them IC101 OKI_M6653A, IC102 74HC273, IC106 BA15218F-E2, IC11 TC7W139, X101 4.09

Commit message: Revise pin descriptions for oki sound chip
Parts:
- IC101: symbol LOOPY_PCM:OKI_M6653A -> LOOPY_PCM:OKI_M6653A_ALT
Connections:
- net AOSC renamed ACMD
- net ARND renamed AST
- net ATST renamed ACH
- net AXT renamed ANAR
Other:
- moved on the sheet: C101, C107, C108, C109, C110, C111, C112, C113, IC101, IC102, IC106, IC11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
